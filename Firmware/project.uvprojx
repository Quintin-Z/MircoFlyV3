# Keil uVision project project.uvprojx, settings and files
target mfv3-firmware (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F405RG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.5.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: mfv3-firmware
  AfterMake: fromelf --bin !L --output mfv3-firmware.bin
  c flags: Optim=1
  c define: RT_USING_ARM_LIBC, USE_STDPERIPH_DRIVER
  c include: .;..\rt-thread\components\cplusplus;..\rt-thread\components\dfs\filesystems\devfs;..\rt-thread\components\dfs\filesystems\elmfat;..\rt-thread\components\dfs\include;..\rt-thread\components\drivers\include;..\rt-thread\components\drivers\sensors;..\rt-thread\components\drivers\spi;..\rt-thread\components\finsh;..\rt-thread\components\libc\armlibc;..\rt-thread\include;..\rt-thread\libcpu\arm\common;..\rt-thread\libcpu\arm\cortex-m4;Libraries\CMSIS\Include;Libraries\CMSIS\ST\STM32F4xx\Include;Libraries\STM32F4xx_StdPeriph_Driver\inc;applications;drivers
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --keep *.o(.rti_fn.*)   --keep *.o(FSymTab) --keep *.o(VSymTab)
  group Applications
    applications/: application.c startup.c
    ./applications/: paltform.cpp test.cpp
  group Drivers
    drivers/: board.c stm32f4xx_it.c usart.c gpio.c stm32f20x_40x_spi.c
    ./drivers/: mpu9250.cpp ms5611.c
  group STM32_StdPeriph
    Libraries/CMSIS/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
    Libraries/CMSIS/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f4xx.s
  group Kernel
    ../rt-thread/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c thread.c timer.c
  group CORTEX-M4
    ../rt-thread/libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
    ../rt-thread/libcpu/arm/common/: backtrace.c div0.c showmem.c
  group CPlusPlus
    ../rt-thread/components/cplusplus/: crt.cpp crt_init.c
  group Filesystem
    ../rt-thread/components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
    ../rt-thread/components/dfs/filesystems/devfs/: console.c devfs.c
    ../rt-thread/components/dfs/filesystems/elmfat/: dfs_elm.c ff.c
    ../rt-thread/components/dfs/filesystems/elmfat/option/: cc932.c
  group DeviceDrivers
    ../rt-thread/components/drivers/misc/: pin.c
    ../rt-thread/components/drivers/serial/: serial.c
    ../rt-thread/components/drivers/spi/: spi_core.c spi_dev.c spi_flash_w25qxx.c
    ../rt-thread/components/drivers/src/: completion.c dataqueue.c pipe.c portal.c ringbuffer.c workqueue.c
  group Sensors
    ../rt-thread/components/drivers/sensors/: sensor.cpp
  group finsh
    ../rt-thread/components/finsh/: shell.c symbol.c cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_var.c finsh_vm.c finsh_token.c
  group libc
    ../rt-thread/components/libc/armlibc/: mem_std.c stubs.c
